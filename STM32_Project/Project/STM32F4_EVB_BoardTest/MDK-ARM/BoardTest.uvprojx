# Keil uVision project BoardTest.uvprojx, settings and files
target STM32F4_EVB (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F417IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_EVB_BoardTest +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM32F4_EVB, USE_STDPERIPH_DRIVER, STM32F40_41xxx, USE_USB_OTG_HS, USE_ULPI_PHY,
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32F4_EVB;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\;..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\;..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\inc;..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c stm32f4xx_it.c fs.c httpd.c httpd_cgi_ssi.c serial_debug.c
  group User Ethernet
    ../src/: netconf.c stm32f4x7_eth_bsp.c tcp_echoclient.c
  group STM32F4_EVB
    ../../../Utilities/STM32_EVAL/STM32F4_EVB/: stm32f4_evb.c stm32f4_evb_fsmc_psram.c stm32f4_evb_i2c_ee.c stm32f4_evb_i2c_tsc.c stm32f4_evb_i2c_gsensor.c stm32f4_evb_sdio_sd.c stm324xg_eval_lcd.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4x7_ETH_Driver
    ../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group CMSIS
    ../src/: system_stm32f4xx.c
  group Common
    ../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427x.s startup_stm32f40xx.s
  group LwIP
    ../../../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group Custom
    ../src/: my_uart.c my_bmp.c my_fatfs.c my_rtc.c
  group FAT_FS
    ../src/: fatfs_drv.c ff.c ccsbcs.c
software components: CMSIS:CORE 4.1.0
