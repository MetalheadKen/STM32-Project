# IAR project STM32_FATFS_USBH_SD.ewp, settings and files
configuration STM324xG-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..; ..\Devices\STM32F4xx; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM32_FatFS_Example_V1.0.0RC2.bin
  ILINK.IlinkOutputFile: STM324xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM322xG-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..; ..\Devices\STM32F2xx; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\..\Utilities\Third_Party\fat_fs\inc
  ILINK.IlinkOutputFile: STM322xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  group Demo/Devices/STM32F2xx
    ../Devices/STM32F2xx/: bsp.c startup_stm32f2xx.s system_stm32f2xx.c usb_bsp.c
  group Demo/Devices/STM32F2xx/STM322xG-EVAL
    ../../../Utilities/STM32_EVAL/stm322xg_eval/: stm322xg_eval.c
    ../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c stm322xg_eval_sdio_sd.c
  group Demo/Devices/STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_tim.c
  group Demo/Devices/STM32F4xx
    ../Devices/STM32F4xx/: bsp.c startup_stm32f4xx.s system_stm32f4xx.c usb_bsp.c
  group Demo/Devices/STM32F4xx/STM324xG-EVAL
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c stm324xg_eval_sdio_sd.c
  group Demo/Devices/STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c
  group Demo/User
    ../: fatfs_drv.c main.c stm32xxx_it.c usbh_usr.c
  group Libraries/STM32_USB/Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group Libraries/STM32_USB/Host/Class/MSC
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group Libraries/STM32_USB/Host/Core
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group Utilities/Common
    ../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group Utilities/FAT_FS
    ../../../Utilities/Third_Party/fat_fs/src/option/: ccsbcs.c
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c
